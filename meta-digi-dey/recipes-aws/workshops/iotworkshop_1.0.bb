# Copyright (C) 2017, Amazon Web Services

SUMMARY = "AWS Partner Workshops"
HOMEPAGE = "https://aws.amazon.com/"

LICENSE = "Apache-2.0"


RDEPENDS_${PN} += "python-pip"

